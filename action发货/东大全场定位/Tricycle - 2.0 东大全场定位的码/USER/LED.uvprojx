# Keil uVision project LED.uvprojx, settings and files
target Tricycle (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\APP;..\BSP;..\BSP\MPU6050;..\BSP\MPU6050\eMPL;..\BSP\IIC;..\SYSTEM\Action_usart;..\BSP\ALGORITHM;..\USMART;..\SYSTEM\pid_usart;..\APP\point
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/Action_usart/: Action_usart.c
    ../SYSTEM/pid_usart/: pid_usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_dma.c
  group README
    ../: readme.txt
  group APP
    ../APP/: task.c task.h control.c control.h protocol.c protocol.h
  group BSP
    ../BSP/: timer2.c timer2.h can1.c can1.h dma.c dma.h pstwo.c pstwo.h
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BSP/IIC/: myiic.c
    ../BSP/ALGORITHM/: PID.h
    ../APP/point/: point.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
